## drivers/i3c/Kconfig
```kconfig
# SPDX-License-Identifier: GPL-2.0

source "$(COMMON_DRIVERS_DIR)/drivers/i3c/master/Kconfig"
```
